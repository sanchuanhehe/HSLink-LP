# Repository sanchuanhehe/HSLink-LP

File README.md:

# HSLink-LP

基于 HSLink Pro 1.2.0 / HPM5301 的双串口调试与低功耗测试工程。

**当前状态：上游布局的降本原理图审阅稿、完整嘉立创 BOM 核价记录及 ARM20 接口。** 已安装 KiCad MCP 和三项社区 skills，原理图由上游原文件复制后，通过 MCP 增改电路和整理文字。上游源码通过 Git 子模块管理。已有110×80mm PCB布局、关键手工布线及结构C参数化样件；PCB尚有399条未连接项，没有新板固件或真实设备通信，不可投板。

## 已确定的目标

- 新整板，单 USB-C，保留 CMSIS-DAP / SWD / JTAG。
- 两路 USB CDC 串口，各带 TX/RX、DTR/RTS；首版信号电平 1.8～3.3 V。
- 目标接口为带键 ARM 20 针，nTRST 第3针、nRESET 第15针；目标供电走独立接口。
- 40 MHz 调试链路验收目标，实际速率受目标芯片及连接条件限制。
- 内置可调供电 1.8～5.0 V / 最高 1 A；外部供电 1.8～5.5 V / 最高 2 A。
- 保留隔离Vref检测；取消DUT_OUT实测电压回读，供电范围不变。
- 外部供电测量仪负责电流测量；测量状态保持目标供电、断开信号及检测支路。
- 25±5°C 条件下，夹具附加电流目标 ≤0.14 µA，必须以整板实测确认。
- Mac 命令行工具和 Python 库；暂不包含图形界面。

电源来源按用户选择采用板上手动切换。电脑控制目标板电源通断，与来源选择分开。

打开 [HSLink-LP.kicad_pro](hardware/design/HSLink-LP.kicad_pro)。接入方式见 [KiCad MCP 与 skills](docs/kicad-integration.md)，降本方案见 [设计说明](docs/cost-down.md)，板上材料 ¥124.9924/板，加配套排线 ¥128.8354/套（10 套材料 ¥1,288.3540，不含制造、运输与采购余料），见 [成本评估](docs/cost.md)，未关闭的设计问题见 [设计审查](hardware/design/README.md)。Python 环境、依赖与执行统一使用 uv。

工作区只保留一份当前设计，历史通过 Git 提交回溯，不再使用版本号目录副本。原理图、符号库、候选 BOM 和验证摘要纳入 Git；KiCad 本机设置、备份、锁文件、导出报告和缓存由 `.gitignore` 排除。临时生成、排版脚本已删除；已安装的 MCP 服务放在用户工具目录。

## 目录

| 目录 | 用途 |
| --- | --- |
| `docs/` | 需求、架构、验收与实施阶段 |
| `hardware/design/` | 唯一的当前 KiCad 工程和项目符号库 |
| `hardware/validation.json` | 原理图文件检查、源文件哈希及各部分验证状态 |
| `hardware/reference/` | 固定版本的上游硬件参考 |
| `hardware/bom/` | 候选器件及验证状态 |
| `firmware/` | 改版固件及板级配置的工作目录 |
| `host/` | Mac / Python 控制工具骨架 |
| `tools/` | 获取固定版本上游源码的辅助工具 |
| `upstream.lock.json` | 上游仓库、版本和本地路径 |

## 开始使用

先阅读 [需求](docs/requirements.md)、[架构](docs/architecture.md) 和 [验证计划](docs/validation.md)。

通过 uv 运行命令行骨架：

```bash
uv run --project host hslink-lp info
```

该命令只显示工程状态，不连接设备。查看上游依赖：

```bash
uv run --python 3.12 tools/fetch_upstream.py --list
```

克隆本工程后，在工程根目录恢复全部上游源码及其嵌套子模块：

```bash
git submodule update --init --recursive --depth=1
uv run --python 3.12 tools/fetch_upstream.py --check
```

也可按需初始化单个上游工程：

```bash
uv run --python 3.12 tools/fetch_upstream.py hardware
uv run --python 3.12 tools/fetch_upstream.py firmware
uv run --python 3.12 tools/fetch_upstream.py sdk
```

SDK 和固件子模块下载可能较大。辅助工具会核对锁文件与 Git 子模块提交，拒绝覆盖已有修改或不同版本的工作区。它不执行上游构建脚本、不安装编译器或全局依赖。维护方法见 [上游工程](docs/upstream.md)，器件资料见 [参考资料](docs/references.md)。

## 当前边界

- 不存在可直接投板的改版电路或可烧录的新固件。
- 40 MHz、1 A/2 A 和低漏电都是设计与验收目标，尚未验证。
- FSA2466 14路在25°C的上限求和已占满140 nA整夹具目标；覆盖20～30°C的全温表值筛选为700 nA，另有U901、线束及PCB，预算仍未闭合。目标信号连接期间必须保持调试器USB供电；USB掉电而目标仍供电的FSA保护不在首版支持范围，未实现掉电保护。
- 不使用原版固件自动识别逻辑驱动改版电源电路。
- 新板需要独立板型、硬件身份和启动时默认关闭的输出控制。

ARM20 针脚、封装和线束见 [接口说明](docs/arm20-interface.md)，[板上 BOM](hardware/bom/candidates.csv)与[配件 BOM](hardware/bom/accessories.csv)分列。现货 20 cm 排线仅作为打样配套，手册绝缘下限不足以保证 0.14 µA，必须通过整夹具漏电及 40 MHz 实测后放行。

2026-11-07侧线程结论已同步：[边界、漏电与电源余量](docs/electrical-margins.md)。VIO反馈及USB侧输入余量已修改，接受逐板校准、±1%目标待实测；R42已按用户接受的806Ω±0.1%低成本打样方案落实，逐板持续1A/过载/短路/温升为投用前必验项，不宣称硬件通过。

当前PCB布局与未完成项见[布局检查](docs/pcb-layout.md)，结构源与STEP/STL见[结构件](hardware/design/mechanical/README.md)。结构费用尚未包含在材料快照中。

## KiCad design hardware/design/HSLink-LP.kicad_pcb

File hardware/design/README.md:

# HSLink-LP 硬件设计

打开 `HSLink-LP.kicad_pro`。唯一工作区基于固定 HSLink Pro 1.2.0 原图增改，参考仓库未修改；版本通过 Git 回溯。2026-11-14当前PCB全布线完成，完整DRC为0一般违规/0未连接/0parity；制造审阅数据含185个SMT位号和8个THT件，结构C已做当前模型检查。仍无生产放行或硬件验收；所选排线实际尺寸等缺项见[制造说明](../../docs/manufacturing.md)。

## 本次设计

- SW601 换为 Dailywell 2MD1T1B1M2QES-5；保留手动来源选择与第二极状态输入。
- VIO 改为 TLV75801 + MCP4726，删除第二套 TPS63811 与电感；主目标可调供电现用 TPS63810YFFR + TPS22950CDDCR。
- 仅保留K601一颗HFD2/005-S：COM接DUT、NO接来源、NC经1k及Q902放电。Vref采用DG2012EDL-T1-GE3，删除K901/Q901/D901和DUT_OUT分压/ADC连接；开关由USB供电。见[优化说明](../../docs/sense-discharge.md)。
- 删除 ADG4612 及其 12 V 升压电路；数字信号仍为四颗 FSA2466。
- 删除不再需要的 TCA9543A 及支路上拉，四个不同地址的 I2C 从设备直接共享总线；VIO DAC 使用 MCP4726A0T-E/CH。
- 本轮换用 Sunlord 三颗电感、WUSB3801、TPS7A2036、1206 输出电容及准确连接器；见 [JLC 设计检查](../../docs/jlc-design-review.md)与[物理引脚表](../../docs/jlc-pinmap.md)。
- 当前原理图204个电气位号（193采购件+11裸铜测试焊盘）；采购件沿用2026-11-07核价快照，板上材料¥124.9924/板；加配套排线¥128.8354/套、10套¥1,288.3540。见[成本](../../docs/cost.md)。
- J801改带键ARM20，nTRST第3针、nRESET第15针，删除J802；VTref/所有目标信号的隔离保留，供电走独立J602。见[接口说明](../../docs/arm20-interface.md)。
- 按用户确认采用 12 颗 SN74LVC1T45DBVR，SOT-23-6；24 颗去耦、13 颗偏置，删除旧 OE 与未用通道。40 MHz 保持待实测，见 [实施说明](../../docs/level-translation.md)。

新增供电、检测页按功能重新分组，器件位号／数值置于主体外，全局标签接短支线，检查两种字体下的实际图面。主控、晶振、启动／复位、主控电源与去耦仍沿用上游布局；34 个符号单元（33 个物理位号）位置和旋转与已记录的上游映射一致。

## 阅读顺序

| 页 | 文件 | 电路 |
|---|---|---|
| 1 | HSLink-LP | 主控、晶振、恢复接口和子页入口 |
| 2 | Power | 上游主控电源、USB 辅助 3.3/3.6 V |
| 3 | Interface | USB-C、CC、ESD、输入限流 |
| 4 | LogicTranslation | 电平转换与开漏复位 |
| 5 | Control | I2C GPIO、共享总线与默认下拉 |
| 6 | Safety | 硬件禁能与放电驱动互锁 |
| 7 | TargetPower | 内置可调输出、DAC/LDO VIO、来源选择、输出继电器 |
| 8 | Disconnect | FSA2466、调试和双串口目标接口 |
| 9 | Sense | 单通道模拟开关隔离Vref检测、受控放电 |

## 测试点

2026-11-12新增TP2～TP11，服务VIO外部校准、电源/故障和互锁时序；TP1保留。高速与目标侧敏感网络复用现有焊盘/接口，不增加长探测支线。原有连接保持，ERC 0错误/0告警；PCB已同步并手工连接10个新增点的局部端点；拆盖后D2mm探测包络无器件干涉，实际探头/装配公差仍待验证。详见[测试点规划](../../docs/test-points.md)和[板上特征表](../bom/pcb-features.csv)。

## 文件验证

2026-11-07 已原地统一为 **KiCad 10**：9 页原理图、2 个本地符号库、6 个本地封装完成原生格式检查/升级。转换前后完整网表一致，ERC 均为 **0 错误、0 告警**；九页图形、文字位置及样式不变。BOM、连接意图和上游参考未改。详见[格式转换记录](../../docs/kicad-integration.md#kicad-10-原生格式统一2026-11-07)及[验证摘要](../validation.json)。以下保留此前电路修改的检查记录；格式转换不关闭既有电气与实板验证问题。

2026-11-07：MCP最终ERC **0错误、0告警**，未增加忽略项。194物理位号、117连接网络、675连接引脚、45个独立NC与预先定义意图一致；58行BOM的位号、MPN、封装与10套阶梯金额已查。

基线8fb837e逐项变换：删除K901/Q901/D901/R55/R56/C62及ADC_VOUT/VOUT_SENSE_IN/SENSE_COIL_LO；U1.26标NC；新增U901和C901。DUT_VREF仅J801.1→U901.5，NO→整个68k/68k/1n采样；NC悬空。DUT_OUT仅J602.1/K601.4。K601/Q902、FSA、ARM20及互锁其余引脚集合完全不变，非实板验收。

双字体PDF各九页；本轮人工查看主控根页和Sense页，修正新电源符号文字与线重叠；其余七张源图与基线字节一致。摘要/哈希见[validation.json](../validation.json)，证据在忽略目录`reports/vref-only-2026-11-07/`。无DUT_OUT实测回读，输出精度、掉压和放电完成只能由外部仪器验证。

器件、连接、库和字段通过已安装 MCP 修改。标准工具对项目库封装临时放置/回读和自由文字编辑的支持缺口由一次性 MCP 适配器补齐；客户端、适配器和缓存用后删除，常驻 MCP 服务未修改。

## 尚未完成

- U501已绑定按原厂图建立的15球YFF封装，0.4mm逃线/钢网/DFM仍待完成；L4 已绑定更大的 MWSA0603S 封装；原有 MCU、FSA、连接器等仍须完整物理映射与 PCB/DFM 审查。
- 来源开关FAQ支持BBM、系列Q触点3A/28VDC覆盖需求；完整-5料号时序与首板双极转换/浪涌仍待确认。P1→P2和第二极改线是未批准建议，本轮保留型号/接线。
- 继电器微小电流、2A温升、浪涌及含续流的释放/抖动待测；Q902栅极掉电瞬态与OFF漏电未验收，50ms仅切换待测初值。MEASURE由K601 NC机械隔离放电，OFF仅MOS关断。
- U901 COM掉电保护不等于零漏电：数据表最大1µA；中间供电斜坡与20/25/30°C实际状态待测。
- 140 nA整夹具目标（20～30°C）未闭合；FSA的25°C上限和已140 nA、全温表值保守和700 nA，另有U901/线束/PCB。USB掉电而目标仍供电的FSA保护不在首版支持范围，连接目标信号期间须保持USB供电。
- VIO电流预算、精度、启动过冲及热待测；TPS63810启动3.3V需隔离编程；R42已改806Ω±0.1%低成本打样方案，典型限流约1.487A，无该档厂家保证上下限；逐板持续1A/过载/短路/温升投用前必验。
- 20cm配套排线的手册绝缘下限5MΩ不足以保证0.14µA；40MHz与漏电待实测，失败须换线束。
- 独立板型、双 CDC、WUSB3801 驱动、真实 HID、DAC 时序及 MEASURE 锁定尚未实现。

MEASURE 保持目标供电，同时断开调试、复位、双 UART 握手、Vref、采样与放电支路；默认保持共地。ERC 通过不等于允许投板。

## 许可

上游 HPM5301 及晶体缓存符号保留在 `libraries/UpstreamCache.kicad_sym`，原 Apache-2.0 许可保留为 `libraries/HSLink-upstream-LICENSE`。未修改 `hardware/reference/`。

2026-11-07边界同步：修正Power/Control/Disconnect三处旧说明，并补充连接目标信号时保持USB供电。重新导出网表/ERC及图面，电气连接未变；140nA、R42和VIO余量仍未验收。见[设计说明](../../docs/electrical-margins.md)。

VIO当前使用USB_5V→TLV75801，反馈10k/2.15k/15.4k；保持DAC和封装，逐板外部校准、±1%目标待验收。见[余量说明](../../docs/electrical-margins.md)。

## 2026-11-12布局重整

183个封装移动/旋转，保留全部逻辑焊盘网络；原生PCB/原理图一致性为0问题。完成关键电源与USB手工路径、安装孔禁布区、接口针序/极性丝印及结构装配模型。原理图ERC为0；PCB一般违规项列表为空，但另有399条未连接报告项，仍不可投板。见[布局约束](../../docs/pcb-layout.md)和[结构样件](mechanical/README.md)。

## 接口与测试点PCB继续整理

在上述布局基线上再调整96个已有封装，前沿从左至右为ARM20、UART A、UART B、DUT电源；调试和两组串口转换器按功能分组、去耦对齐。新增TP2～TP11及局部手工走线，当前211个封装（204个电气位号、4安装孔、3基准点）。一般几何违规0项、原理图parity0项，另有399条未连接，仍不可投板。该阶段源哈希和实际模型证据见`hardware/validation.json`的`layout_testpoint_continuation`，不把旧阶段记录当成当前整板通过结论。

Parts:
C1, C2: 15p; C_0603_1608Metric; MPN CL10C150JB8NNNC; LCSC C1644
C21: 100n; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
J1: ISP / SERVICE; PinHeader_1x06_P2.54mm_Vertical; MPN PZ254V-11-06P; LCSC C492405
R1, R2: 22R; R_0603_1608Metric; MPN 0603WAF220JT5E; LCSC C23345
R3, R4, R5: 10k; R_0603_1608Metric; MPN 0603WAF1002T5E; LCSC C25804
R6, R7, R8: 100k; R_0603_1608Metric; MPN 0603WAF1003T5E; LCSC C25803
SW1: BOOT1; SW_Push_1P1T_XKB_TS-1187A; MPN TS-1187A-B-A-B; LCSC C318884
SW2: RESET; SW_Push_1P1T_XKB_TS-1187A; MPN TS-1187A-B-A-B; LCSC C318884
TP1: SPARE_GPIO; TestPoint_Pad_D1.0mm; MPN PCB test pad
U1: HPM5301IEG1; QFN-48-1EP_6x6mm_P0.4mm_EP4.2x4.2mm
U2: TLV803EA30DBZR; SOT-23; MPN TLV803EA30DBZR; LCSC C5218924
Y1: 24MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; MPN X322524MOB4SI; LCSC C70590

Connections:
ADC_VREF: U1.27 (PB08/TMR0.COMP1/URT2.TXD/I2C2.SCL/SPI2.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); also elsewhere on the board
BOOT0: R3.1, U1.8 (PA02/TMR1.COMP1/URT0.DE/URT0.RTS/I2C0.S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)
BOOT1: J1.5, R4.1, SW1.1, U1.7 (PA03/TMR1.CAPT1/URT0.CTS/I2C0.SDA/SPI3.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)
CC_INTn: U1.48 (PA05/TMR1.COMP2/URT1.DE/URT1.RTS/SPI0.S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); also elsewhere on the board
FAULTn: U1.18 (PY01/URT0.RXD/WDG0.RST/USB0.OC/PMIC_PY0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); also elsewhere on the board
GND: C1.2, C2.2, C21.2, J1.2, R3.2, R4.2, R6.2, R7.2, R8.2, SW2.2, U1.14 (WAKEUP), U2.1 (GND), Y1.2, Y1.4; also elsewhere on the board
I2C_SCL: U1.46 (PA07/TMR0.COMP0/URT1.TXD/I2C1.SCL/SPI0.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); also elsewhere on the board
I2C_SDA: U1.47 (PA06/TMR0.CAPT0/URT1.RXD/I2C1.SDA/SPI0.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); also elsewhere on the board
NRST_DRIVE: U1.20 (PB15/TMR0.COMP3/URT3.TXD/SPI2.DAT3/TRGM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); also elsewhere on the board
NTRST_DRIVE: U1.21 (PB14/URT3.RXD/SPI2.DAT2/TRGM0.P02/ADC0.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); also elsewhere on the board
unnamed: R2.2, U1.40 (PA28/I2C3.SDA/SPI1.MISO/XPI0.CA_D0/TRGM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)
unnamed: R1.2, U1.39 (PA29/I2C3.SCL/SPI1.MOSI/XPI0.CA_D2/TRGM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)
P3V3: J1.1, R5.1, SW1.2, U2.3 (VDD); also elsewhere on the board
POWER_REQ: R7.1, U1.37 (PA31/SPI1.DAT3/XPI0.CA_CS0/TRGM0.P07/US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); also elsewhere on the board
SIG_ARM_REQ: R6.1, U1.1 (PA04/URT1.CTS/SPI0.CS0/TRGM0.P04/JTAG.T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); also elsewhere on the board
SPARE_GPIO: TP1.1, U1.19 (PY00/URT0.TXD/USB0.ID/PMIC_PY00/PURT.TX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)
SPI_CS: U1.25 (PB10/TMR0.COMP2/URT2.DE/URT2.RTS/SPI2.C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), U1.42 (PA26/SPI1.CS0/XPI0.CA_D3/TRGM0.P02)
SWD_DIR: U1.38 (PA30/SPI1.DAT2/XPI0.CA_D1/TRGM0.P06/USB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); also elsewhere on the board
SWD_MCU: R1.1, R2.1; also elsewhere on the board
SYS_RESETn: C21.1, J1.6, R5.2, SW2.1, U1.13 (~RESETN), U2.2 (RESETn); also elsewhere on the board
TCK_MCU: U1.24 (PB11/URT2.CTS/SPI2.SCLK/ACMP.COMP1/ADC0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), U1.41 (PA27/SPI1.SCLK/XPI0.CA_SCLK/TRGM0.P03); also elsewhere on the board
TDI_MCU: U1.22 (PB13/TMR1.COMP3/URT3.DE/URT3.RTS/I2C3.S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); also elsewhere on the board
TDO_MCU: U1.23 (PB12/URT3.CTS/I2C3.SDA/SPI2.MISO/TRGM0.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); also elsewhere on the board
UART_A_RX: U1.3 (PA09/TMR0.CAPT1/URT2.RXD/I2C2.SDA/SPI3.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); also elsewhere on the board
UART_A_TX: U1.2 (PA08/TMR0.COMP1/URT2.TXD/I2C2.SCL/SPI3.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); also elsewhere on the board
UART_B_RX: J1.4, U1.11 (PA01/TMR1.CAPT0/URT0.RXD/TRGM0.P01/ACMP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); also elsewhere on the board
UART_B_TX: J1.3, U1.12 (PA00/TMR1.COMP0/URT0.TXD/TRGM0.P00); also elsewhere on the board
USB_DM: U1.43 (PA25/I2C2.SDA/SPI1.CS1/XPI0.CA_DQS/TRGM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); also elsewhere on the board
USB_DP: U1.44 (PA24/I2C2.SCL/SPI1.CS2/XPI0.CA_CS1/TRGM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); also elsewhere on the board
VIO_EN: R8.1, U1.4 (PA10/TMR0.COMP2/URT2.DE/URT2.RTS/SPI3.C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); also elsewhere on the board
XTALI: C1.1, U1.35 (XTALI), Y1.1
XTALO: C2.1, U1.36 (XTALO), Y1.3

Notes on the sheet:
启动配置 / 默认关闭
HSLink-LP 设计审阅稿
基于 HSLink Pro 1.2.0 审阅稿；未完成硬件验证
复位监控与手动复位
晶振 / 24 MHz
服务口：禁止 UART_B 日志输出

Parts:
C26: 100n; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
R17, R18: 4.7k; R_0603_1608Metric; MPN 0603WAF4701T5E; LCSC C23162
R23, R24, R25, R26, R27, R28, R29: 100k; R_0603_1608Metric; MPN 0603WAF1003T5E; LCSC C25803
U201: TCA9539PWR; TSSOP-24_4.4x7.8mm_P0.65mm; MPN TCA9539PWR; LCSC C131972

Connections:
DEBUG_REQ: R23.1, U201.8 (P04); also elsewhere on the board
DISCH_REQ: R28.1, U201.14 (P11); also elsewhere on the board
FAULTn: U201.19 (P16); also elsewhere on the board
GND: C26.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, U201.2 (A1), U201.12 (GND), U201.21 (A0); also elsewhere on the board
I2C_SCL: R17.1, U201.22 (SCL); also elsewhere on the board
I2C_SDA: R18.1, U201.23 (SDA); also elsewhere on the board
INT_EN: R29.1, U201.15 (P12); also elsewhere on the board
P3V3: C26.1, R17.2, R18.2, U201.24 (VCC); also elsewhere on the board
RESET_REQ: R26.1, U201.11 (P07); also elsewhere on the board
SENSE_REQ: R27.1, U201.13 (P10); also elsewhere on the board
SOURCE_EXT: U201.20 (P17); also elsewhere on the board
SYS_RESETn: U201.3 (RESETn); also elsewhere on the board
UART_A_DTR: U201.4 (P00); also elsewhere on the board
UART_A_REQ: R24.1, U201.9 (P05); also elsewhere on the board
UART_A_RTS: U201.5 (P01); also elsewhere on the board
UART_B_DTR: U201.6 (P02); also elsewhere on the board
UART_B_REQ: R25.1, U201.10 (P06); also elsewhere on the board
UART_B_RTS: U201.7 (P03); also elsewhere on the board
USB_TIER1: U201.17 (P14); also elsewhere on the board
USB_TIER2: U201.18 (P15); also elsewhere on the board

Notes on the sheet:
MEASURE 锁定后，CDC、DTR/RTS 与 DAP 均不得隐式重连。
共享 I2C 总线（3.3 V）
GPIO 默认输入：先写输出寄存器 0，再配置方向。
TCA9539 / 0x74
分组请求默认下拉
I2C_SCL / I2C_SDA：共用 4.7k 上拉。 0x68 WUSB3801（USB-C） 0x60 MCP4726A0（VIO DAC） 0x74 TCA9539（GPIO） 0x75 TPS63811（目标供电） 100 kHz 起步，400 kHz 须验证上升时间。 DAC 使用 VDD 参考，初始化后再使能 VIO。

Parts:
C39: 10u; C_0603_1608Metric; MPN CL10A106KP8NNNC; LCSC C19702
C40, C41: 47u; C_1206_3216Metric; MPN CL31A476MPHNNNE; LCSC C96123
C42, C46: 100n; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
C43, C44: 4.7u/10V; C_0603_1608Metric; MPN TCC0603X7R475K100CT; LCSC C18185770
C47: 1u; C_0603_1608Metric; MPN CL10B105KP8NNNC; LCSC C95843
D601: 1N4148W; D_SOD-123; MPN 1N4148W; LCSC C81598
J601: EXT 1.8-5.5V; TerminalBlock_KEFA_KF128_5.08_1x02; MPN KF128-5.08-2P-AA; LCSC C474952
J602: DUT POWER; TerminalBlock_KEFA_KF128_5.08_1x02; MPN KF128-5.08-2P-AA; LCSC C474952
K601: HFD2/005-S; Relay_Hongfa_HFD2; MPN HFD2/005-S; LCSC C42415145
L4: 470nH; L_Sunlord_MWSA0603S; MPN MWSA0603S-R47MT; LCSC C408439
Q601: AO3400A; SOT-23; MPN AO3400A; LCSC C20917
R42: 806R; R_0603_1608Metric; MPN RT0603BRD07806RL; LCSC C861567
R44, R45, R63: 100k; R_0603_1608Metric; MPN 0603WAF1003T5E; LCSC C25803
R58: 10k; R_0603_1608Metric; Tolerance 0.1%; MPN RT0603BRD0710KL; LCSC C95204
R59: 2.15k; R_0603_1608Metric; Tolerance 0.1%; MPN RT0603BRD072K15L; LCSC C861292
R60: 15.4k; R_0603_1608Metric; Tolerance 0.1%; MPN RT0603BRD0715K4L; LCSC C861142
SW601: 2MD1T1B1M2QES-5; SW_Dailywell_2MD1T1B1M2QES_5; MPN 2MD1T1B1M2QES-5; LCSC C908282
TP2: VIO_LOCAL; TestPoint_Pad_D1.5mm; MPN PCB test pad
TP3: GND; TestPoint_Pad_D1.5mm; MPN PCB test pad
TP4: P3V6_SW; TestPoint_Pad_D1.5mm; MPN PCB test pad
TP9: FAULTn; TestPoint_Pad_D1.5mm; MPN PCB test pad
TP10: VIO_EN; TestPoint_Pad_D1.5mm; MPN PCB test pad
U501: TPS63810YFFR; Texas_YFF0015_1.344x2.255mm_P0.4mm; MPN TPS63810YFFR; LCSC C1852139
U502: TLV75801PDRVR; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm; MPN TLV75801PDRVR; LCSC C2876308
U503: TPS22950CDDCR; SOT-23-6; MPN TPS22950CDDCR; LCSC C7587833
U504: MCP4726A0T-E/CH; SOT-23-6; MPN MCP4726A0T-E/CH; LCSC C191581

Connections:
/内置电源、VIO 与输出来源选择/POWER_COIL_LO: D601.2 (A), K601.16 (COIL-), Q601.3 (D)
/内置电源、VIO 与输出来源选择/VIO_DAC: R60.1, U504.1 (VOUT)
/内置电源、VIO 与输出来源选择/VIO_FB: R58.2, R59.1, R60.2, U502.2 (FB)
DISCH_FEED: K601.6 (NC1); also elsewhere on the board
DUT_OUT: J602.1, K601.4 (COM1)
EXT_INPUT: J601.1, SW601.3 (EXT)
FAULTn: TP9.1, U503.6 (FLTn); also elsewhere on the board
GND: C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C46.2, C47.2, J601.2, J602.2, Q601.2 (S), R42.2, R44.2, R45.2, R59.2, R63.2, SW601.4 (INT_ID), TP3.1, U501.B1 (VSEL), U501.C1 (AGND), U501.C2 (PGND), U501.C3 (PGND), U502.3 (GND), U502.7 (GND), U503.3 (GND), U504.2 (VSS), U504.6 (VREF); also elsewhere on the board
I2C_SCL: U501.D1 (SCL), U504.5 (SCL); also elsewhere on the board
I2C_SDA: U501.E1 (SDA), U504.4 (SDA); also elsewhere on the board
INT_EN: U501.A1 (EN), U503.1 (ON); also elsewhere on the board
INT_PROTECTED: C47.1, SW601.1 (INT), U503.5 (VOUT)
INT_RAW: C40.1, C41.1, U501.E2 (VOUT), U501.E3 (VOUT), U503.2 (VIN)
unnamed: L4.1, U501.B2 (LX1), U501.B3 (LX1)
unnamed: L4.2, U501.D2 (LX2), U501.D3 (LX2)
unnamed: R42.1, U503.4 (ILIM)
P3V3: C46.1, SW601.6 (EXT_ID), U504.3 (VDD); also elsewhere on the board
P3V6_SW: TP4.1; also elsewhere on the board
POWER_SAFE: Q601.1 (G), R44.1; also elsewhere on the board
SOURCE_EXT: R45.1, SW601.5 (ID_COM); also elsewhere on the board
SOURCE_POWER: K601.8 (NO1), SW601.2 (COM)
USB_5V: C39.1, C42.1, C43.1, D601.1 (K), K601.1 (COIL+), U501.A2 (VIN), U501.A3 (VIN), U502.6 (IN); also elsewhere on the board
VIO_EN: R63.1, TP10.1, U502.4 (EN); also elsewhere on the board
VIO_LOCAL: C44.1, R58.1, TP2.1, U502.1 (OUT); also elsewhere on the board

Notes on the sheet:
内置支路限流
内置输出 1.8～5.0 V
电源操作与验证 先关输出，再切来源；外部限流由仪器承担。 继电器线圈由 USB 供电，测量保持共地。 电流能力、触点压降及微小电流可靠性待实测。
DAC：VDD 参考 / 1x；写入并回读后再使能 VIO。
VIO 1.8～3.3 V：DAC + LDO（USB 侧）
K601：COM 接 DUT；NO 接来源；NC 接放电支路

Parts:
C3, C4, C34: 22u; C_0603_1608Metric; MPN CL10A226MP8NUNE; LCSC C86295
C5, C33, C36: 10u; C_0603_1608Metric; MPN CL10A106KP8NNNC; LCSC C19702
C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C18, C20: 100n; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
C17, C19: 4.7u; C_0603_1608Metric; MPN TCC0603X7R475K100CT; LCSC C18185770
C35: 1u; C_0603_1608Metric; MPN CL10B105KP8NNNC; LCSC C95843
L1: 4.7uH; L_Sunlord_SPH4018; MPN SPH4018H4R7MT; LCSC C98400
L2: 2.2uH; L_Sunlord_SPH4018; MPN SPH4018H2R2MT; LCSC C370436
R38: 300k; R_0603_1608Metric; MPN 0603WAF3003T5E; LCSC C23024
R39: 100k; R_0603_1608Metric; MPN 0603WAF1003T5E; LCSC C25803
R401: 150k; R_0603_1608Metric; MPN 0603WAF1503T5E; LCSC C22807
U1: HPM5301IEG1; QFN-48-1EP_6x6mm_P0.4mm_EP4.2x4.2mm; MPN HPM5301IEG1; LCSC C49451864
U401: TLV62568DBVR; SOT-23-5; MPN TLV62568DBVR; LCSC C163219
U402: TPS7A2036PDBVR; SOT-23-5; MPN TPS7A2036PDBVR; LCSC C2873626

Connections:
GND: C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C33.2, C34.2, C35.2, C36.2, R39.2, U1.30 (VREFL), U1.49 (VSS), U401.2 (GND), U402.2 (GND); also elsewhere on the board
unnamed: R38.2, R401.1
unnamed: C17.1, C18.1, U1.10 (VDD_OTPCAP)
unnamed: C19.1, C20.1, U1.17 (VDD_PMCCAP)
unnamed: R39.1, R401.2, U401.5 (FB)
unnamed: L2.1, U401.3 (SW)
P3V3: C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C34.1, L2.2, R38.1, U1.6 (VIO_B00), U1.16 (VPMC), U1.29 (VIO_B01), U1.31 (VREFH), U1.32 (VANA), U1.34 (VIO_B00); also elsewhere on the board
P3V6_SW: C36.1, U402.5 (OUT); also elsewhere on the board
SOC_SW: L1.2, U1.15 (DCDC_LP)
USB_5V: C33.1, C35.1, U401.1 (EN), U401.4 (VIN), U402.1 (IN), U402.3 (EN); also elsewhere on the board
VDD_SOC: C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, L1.1, U1.5 (VDD_SOC), U1.9 (VDD_SOC), U1.28 (VDD_SOC), U1.33 (VDD_SOC), U1.45 (VDD_SOC)

Notes on the sheet:
上游 MCU 电源单元与去耦布局
控制电源 3.3 V
检测 / 放电改为 5 V 机械继电器，已删除本分区升压电路。 3.6 V 辅助电源同时供给 FSA2466 与 VIO LDO。
所有辅助电流取自 USB；不进入外部仪器测量路径。
辅助电源说明
信号开关与 VIO 前级 3.6 V

Parts:
C61: 1n; C_0603_1608Metric; MPN CL10B102KB8NNNC; LCSC C1588
C901: 100n; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
Q902: AO3400A; SOT-23; MPN AO3400A; LCSC C20917
R53, R54: 68k; R_0603_1608Metric; Tolerance 0.1%; MPN RT0603BRD0768KL; LCSC C705793
R57: 1k; R_0603_1608Metric; MPN 0603WAF1001T5E; LCSC C21190
R61, R62: 100k; R_0603_1608Metric; MPN 0603WAF1003T5E; LCSC C25803
U901: DG2012EDL-T1-GE3; SOT-363_SC-70-6; MPN DG2012EDL-T1-GE3; LCSC C2673178

Connections:
/可断开检测与目标放电/VREF_SENSE_IN: R53.1, U901.6 (NO)
ADC_VREF: C61.1, R53.2, R54.1; also elsewhere on the board
DISCH_FEED: R57.1; also elsewhere on the board
DISCH_ON: Q902.1 (G), R62.1; also elsewhere on the board
DUT_VREF: U901.5 (COM); also elsewhere on the board
GND: C61.2, C901.2, Q902.2 (S), R54.2, R61.2, R62.2, U901.3 (GND); also elsewhere on the board
unnamed: Q902.3 (D), R57.2
SENSE_ON: R61.1, U901.1 (IN); also elsewhere on the board
USB_5V: C901.1, U901.2 (V+); also elsewhere on the board

Notes on the sheet:
Vref 检测：单通道模拟开关隔离完整采样支路
U901 默认断开；仅显式允许检测时接通 NO。 Vref：1.8～3.3 V；68k / 68k，1n 滤波。 DUT_OUT 电压回读已取消；设定值不是实测值。
开关与继电器由 USB 侧供电；地线保持共地。USB 掉电与整板漏电均待实测。
受控放电：由 K601 常闭触点机械隔离
K601 NC → R57 → Q902：仅显式放电。 先断供电，等待释放/抖动稳定，再使能 MOS。 恢复供电先关 MOS；50 ms 为待测初值。
