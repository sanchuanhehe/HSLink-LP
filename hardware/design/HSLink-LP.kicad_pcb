# Repository sanchuanhehe/HSLink-LP (continued)

## KiCad design hardware/design/HSLink-LP.kicad_pcb (continued)

Parts:
C48, C49, C50, C51, C52, C53, C54, C55, C701, C702, C703, C704, C705, C706, C707, C708, C709, C710, C711, C712, C713, C714, C715, C716: 100n; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
Q701, Q702: 2N7002; SOT-23; MPN 2N7002; LCSC C8545
R49, R50, R701, R702, R703, R704, R705, R706, R707, R708, R709, R710, R711, R712, R713: 100k; R_0603_1608Metric; MPN 0603WAF1003T5E; LCSC C25803
R51, R52: 10k; R_0603_1608Metric; MPN 0603WAF1002T5E; LCSC C25804
U701, U702, U703, U704, U705, U706, U707, U708, U709, U710, U711, U712: SN74LVC1T45DBVR; SOT-23-6; MPN SN74LVC1T45DBVR; LCSC C7843

Connections:
F_NRST: Q701.3 (D), R51.1; also elsewhere on the board
F_NTRST: Q702.3 (D), R52.1; also elsewhere on the board
F_SWDIO: R702.1, U702.4 (B); also elsewhere on the board
F_TCK: U701.4 (B); also elsewhere on the board
F_TDI: U703.4 (B); also elsewhere on the board
F_TDO: R704.1, U704.4 (B); also elsewhere on the board
F_UART_A_DTR: U707.4 (B); also elsewhere on the board
F_UART_A_RTS: U708.4 (B); also elsewhere on the board
F_UART_A_RX: R706.1, U706.4 (B); also elsewhere on the board
F_UART_A_TX: U705.4 (B); also elsewhere on the board
F_UART_B_DTR: U711.4 (B); also elsewhere on the board
F_UART_B_RTS: U712.4 (B); also elsewhere on the board
F_UART_B_RX: R710.1, U710.4 (B); also elsewhere on the board
F_UART_B_TX: U709.4 (B); also elsewhere on the board
GND: C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C701.2, C702.2, C703.2, C704.2, C705.2, C706.2, C707.2, C708.2, C709.2, C710.2, C711.2, C712.2, C713.2, C714.2, C715.2, C716.2, Q701.2 (S), Q702.2 (S), R49.2, R50.2, R701.2, R703.2, R713.2, U701.2 (GND), U702.2 (GND), U703.2 (GND), U704.2 (GND), U704.5 (DIR), U705.2 (GND), U706.2 (GND), U706.5 (DIR), U707.2 (GND), U708.2 (GND), U709.2 (GND), U710.2 (GND), U710.5 (DIR), U711.2 (GND), U712.2 (GND); also elsewhere on the board
NRST_DRIVE: Q701.1 (G), R49.1; also elsewhere on the board
NTRST_DRIVE: Q702.1 (G), R50.1; also elsewhere on the board
P3V3: C48.1, C50.1, C52.1, C54.1, C701.1, C703.1, C705.1, C707.1, C709.1, C711.1, C713.1, C715.1, R705.1, R707.1, R708.1, R709.1, R711.1, R712.1, U701.1 (VCCA), U701.5 (DIR), U702.1 (VCCA), U703.1 (VCCA), U703.5 (DIR), U704.1 (VCCA), U705.1 (VCCA), U705.5 (DIR), U706.1 (VCCA), U707.1 (VCCA), U707.5 (DIR), U708.1 (VCCA), U708.5 (DIR), U709.1 (VCCA), U709.5 (DIR), U710.1 (VCCA), U711.1 (VCCA), U711.5 (DIR), U712.1 (VCCA), U712.5 (DIR); also elsewhere on the board
SWD_DIR: R713.1, U702.5 (DIR); also elsewhere on the board
SWD_MCU: U702.3 (A); also elsewhere on the board
TCK_MCU: R701.1, U701.3 (A); also elsewhere on the board
TDI_MCU: R703.1, U703.3 (A); also elsewhere on the board
TDO_MCU: U704.3 (A); also elsewhere on the board
UART_A_DTR: R707.2, U707.3 (A); also elsewhere on the board
UART_A_RTS: R708.2, U708.3 (A); also elsewhere on the board
UART_A_RX: U706.3 (A); also elsewhere on the board
UART_A_TX: R705.2, U705.3 (A); also elsewhere on the board
UART_B_DTR: R711.2, U711.3 (A); also elsewhere on the board
UART_B_RTS: R712.2, U712.3 (A); also elsewhere on the board
UART_B_RX: U710.3 (A); also elsewhere on the board
UART_B_TX: R709.2, U709.3 (A); also elsewhere on the board
VIO_LOCAL: C49.1, C51.1, C53.1, C55.1, C702.1, C704.1, C706.1, C708.1, C710.1, C712.1, C714.1, C716.1, R51.2, R52.2, R702.2, R704.2, R706.2, R710.2, U701.6 (VCCB), U702.6 (VCCB), U703.6 (VCCB), U704.6 (VCCB), U705.6 (VCCB), U706.6 (VCCB), U707.6 (VCCB), U708.6 (VCCB), U709.6 (VCCB), U710.6 (VCCB), U711.6 (VCCB), U712.6 (VCCB); also elsewhere on the board

Notes on the sheet:
SWD_DIR 默认接收
调试：SWCLK / SWDIO / TDI / TDO；40 MHz 验收目标，待实测
独立串口 A：TX / RX / DTR / RTS
VCCA = P3V3；VCCB = VIO_LOCAL（1.8～3.3 V）。 12 颗均无 OE；FSA 承担信号断开。 调压前停传输并断开 FSA；测量锁不得自动解除。 弱偏置位于夹具侧，断开后不直接加载 DUT。
开漏复位（仍经 FSA 断开）
独立串口 B：TX / RX / DTR / RTS

Parts:
C56, C57, C58, C59: 100n; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
J801: ARM 20P KEYED; IDC-Header_2x10_P2.54mm_Vertical; MPN 2.54-2*10P简牛; LCSC C3405
J803: UART A; PinHeader_1x05_P2.54mm_Vertical; MPN PZ254V-11-05P; LCSC C492404
J804: UART B; PinHeader_1x05_P2.54mm_Vertical; MPN PZ254V-11-05P; LCSC C492404
U801, U802, U803, U804: FSA2466UMX; UQFN-16_1.8x2.6mm_P0.4mm; MPN FSA2466UMX; LCSC C457657

Connections:
DEBUG_ON: U801.2 (1S), U801.10 (2S); also elsewhere on the board
DUT_NRST: J801.15, U804.15 (1B1)
DUT_NTRST: J801.3, U804.3 (2B1)
DUT_SWDIO: J801.7, U801.15 (1B1)
DUT_TCK: J801.9, U801.3 (2B1)
DUT_TDI: J801.5, U801.7 (3B1)
DUT_TDO: J801.13, U801.11 (4B1)
DUT_VREF: J801.1; also elsewhere on the board
F_NRST: U804.16 (1A); also elsewhere on the board
F_NTRST: U804.4 (2A); also elsewhere on the board
F_SWDIO: U801.16 (1A); also elsewhere on the board
F_TCK: U801.4 (2A); also elsewhere on the board
F_TDI: U801.8 (3A); also elsewhere on the board
F_TDO: U801.12 (4A); also elsewhere on the board
F_UART_A_DTR: U802.8 (3A); also elsewhere on the board
F_UART_A_RTS: U802.12 (4A); also elsewhere on the board
F_UART_A_RX: U802.4 (2A); also elsewhere on the board
F_UART_A_TX: U802.16 (1A); also elsewhere on the board
F_UART_B_DTR: U803.8 (3A); also elsewhere on the board
F_UART_B_RTS: U803.12 (4A); also elsewhere on the board
F_UART_B_RX: U803.4 (2A); also elsewhere on the board
F_UART_B_TX: U803.16 (1A); also elsewhere on the board
GND: C56.2, C57.2, C58.2, C59.2, J801.4, J801.6, J801.8, J801.10, J801.12, J801.14, J801.16, J801.18, J801.20, J803.5, J804.5, U801.6 (GND), U802.6 (GND), U803.6 (GND), U804.6 (GND), U804.10 (2S); also elsewhere on the board
unnamed: J803.1, U802.15 (1B1)
unnamed: J803.2, U802.3 (2B1)
unnamed: J803.3, U802.7 (3B1)
unnamed: J803.4, U802.11 (4B1)
unnamed: J804.1, U803.15 (1B1)
unnamed: J804.2, U803.3 (2B1)
unnamed: J804.3, U803.7 (3B1)
unnamed: J804.4, U803.11 (4B1)
P3V6_SW: C56.1, C57.1, C58.1, C59.1, U801.14 (VCC), U802.14 (VCC), U803.14 (VCC), U804.14 (VCC); also elsewhere on the board
RESET_ON: U804.2 (1S); also elsewhere on the board
UART_A_ON: U802.2 (1S), U802.10 (2S); also elsewhere on the board
UART_B_ON: U803.2 (1S), U803.10 (2S); also elsewhere on the board

Notes on the sheet:
nTRST → J801.3 nRESET → J801.15 RESET_ON = 0 时均断开
FSA2466：A → B1 为连接，B0 悬空。控制 0 = 断开。 信号仅 1.8～3.3 V；USB 掉电隔离不保证。
ARM20 / 2.54 mm / 带键 NC：2、11、17、19；接口不供电 VTref 经 K901 检测断开；目标供电用 J602
RESET / nRESET & nTRST
UART A / TX RX DTR RTS
DEBUG / SWD & JTAG
UART B / TX RX DTR RTS

Parts:
C28, C29, C30, C31: 100n; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
R30, R31, R32, R33, R34, R35, R36, R37: 100k; R_0603_1608Metric; MPN 0603WAF1003T5E; LCSC C25803
TP5: POWER_SAFE; TestPoint_Pad_D1.5mm; MPN PCB test pad
TP6: DISCH_ON; TestPoint_Pad_D1.5mm; MPN PCB test pad
TP7: SENSE_ON; TestPoint_Pad_D1.5mm; MPN PCB test pad
TP8: SIG_ARM; TestPoint_Pad_D1.5mm; MPN PCB test pad
TP11: GND; TestPoint_Pad_D1.5mm; MPN PCB test pad
U301, U302, U303: SN74LVC08APWR; TSSOP-14_4.4x5mm_P0.65mm; MPN SN74LVC08APWR; LCSC C465737
U304: SN74LVC1G04DBVR; SOT-23-5; MPN SN74LVC1G04DBVR; LCSC C7827

Connections:
DEBUG_ON: R32.1, U301.8 (3Y); also elsewhere on the board
DEBUG_REQ: U301.9 (3A); also elsewhere on the board
DISCH_ARM: U302.11 (4Y), U303.1 (1A)
DISCH_ON: R37.1, TP6.1, U303.3 (1Y); also elsewhere on the board
DISCH_REQ: U302.12 (4A); also elsewhere on the board
GND: C28.2, C29.2, C30.2, C31.2, R30.2, R31.2, R32.2, R33.2, R34.2, R35.2, R36.2, R37.2, TP11.1, U301.7 (GND), U302.7 (GND), U303.4 (2A), U303.5 (2B), U303.7 (GND), U303.9 (3A), U303.10 (3B), U303.12 (4A), U303.13 (4B), U304.3 (GND); also elsewhere on the board
unnamed: U303.2 (1B), U304.4 (Y)
P3V3: C28.1, C29.1, C30.1, C31.1, U301.14 (VCC), U302.14 (VCC), U303.14 (VCC), U304.5 (VCC); also elsewhere on the board
POWER_REQ: U301.4 (2A); also elsewhere on the board
POWER_SAFE: R31.1, TP5.1, U301.6 (2Y), U304.2 (A); also elsewhere on the board
RESET_ON: R35.1, U302.6 (2Y); also elsewhere on the board
RESET_REQ: U302.4 (2A); also elsewhere on the board
SENSE_ON: R36.1, TP7.1, U302.8 (3Y); also elsewhere on the board
SENSE_REQ: U302.9 (3A); also elsewhere on the board
SIG_ARM: R30.1, TP8.1, U301.3 (1Y), U301.10 (3B), U301.13 (4B), U302.2 (1B), U302.5 (2B), U302.10 (3B), U302.13 (4B)
SIG_ARM_REQ: U301.1 (1A); also elsewhere on the board
SYS_RESETn: U301.2 (1B), U301.5 (2B); also elsewhere on the board
UART_A_ON: R33.1, U301.11 (4Y); also elsewhere on the board
UART_A_REQ: U301.12 (4A); also elsewhere on the board
UART_B_ON: R34.1, U302.3 (1Y); also elsewhere on the board
UART_B_REQ: U302.1 (1A); also elsewhere on the board

Notes on the sheet:
分组使能
放电互锁：输出供电开启时禁止放电
SIG_ARM = SIG_ARM_REQ & SYS_RESETn POWER_SAFE = POWER_REQ & SYS_RESETn DISCH_ON = DISCH_REQ & SIG_ARM & !POWER_SAFE
全局使能与默认断开

Schematic: Interface.kicad_sch, USB-C、输入保护与功率预算

Parts:
C22: 100n; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
C23: 4.7n; C_0603_1608Metric; MPN CL10B472KB8NNNC; LCSC C1621
C24: 1u; C_0603_1608Metric; MPN CL10B105KP8NNNC; LCSC C95843
C25: 22u; C_0603_1608Metric; MPN CL10A226MP8NUNE; LCSC C86295
D101, D102: TPD2E2U06DRLR; SOT-553; MPN TPD2E2U06DRLR; LCSC C1972959
J101: USB4105-GF-A; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal; MPN USB4105-GF-A; LCSC C3020560
Q101, Q102: 2N7002; SOT-23; MPN 2N7002; LCSC C8545
R9: 0R; R_0603_1608Metric; MPN 0603WAF0000T5E; LCSC C21189
R10, R16: 10k; R_0603_1608Metric; MPN 0603WAF1002T5E; LCSC C25804
R11: 4.99k; R_0603_1608Metric; MPN 0603WAF4991T5E; LCSC C23046
R12: 2.21k; R_0603_1608Metric; MPN 0603WAF2211T5E; LCSC C22903
R13, R15: 100k; R_0603_1608Metric; MPN 0603WAF1003T5E; LCSC C25803
R14: 1.50k; R_0603_1608Metric; MPN 0603WAF1501T5E; LCSC C22843
U101: WUSB3801Q-12/TR; WillSemi_QFN1616_12L; MPN WUSB3801Q-12/TR; LCSC C2931342
U102: TPS259531DSGR; Texas_DSG0008A_WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm; MPN TPS259531DSGR; LCSC C2155674

Connections:
CC_INTn: R10.1, U101.6 (INTB); also elsewhere on the board
FAULTn: R16.1, U102.6 (FLTn); also elsewhere on the board
GND: C22.2, C23.2, C24.2, C25.2, D101.4 (GND), D102.4 (GND), J101.A1 (GND), J101.A12 (GND), J101.B1 (GND), J101.B12 (GND), J101.SH (SHIELD), Q101.2 (S), Q102.2 (S), R11.2, R13.2, R15.2, U101.3 (ROLE), U101.10 (GND), U101.11 (ENB), U102.8 (GND), U102.9 (EP); also elsewhere on the board
I2C_SCL: U101.8 (SCL); also elsewhere on the board
I2C_SDA: U101.7 (SDA); also elsewhere on the board
unnamed: J101.A5 (CC1), U101.1 (CC1)
unnamed: J101.B5 (CC2), U101.2 (CC2)
unnamed: Q101.3 (D), R12.2
unnamed: Q102.3 (D), R14.2
unnamed: R9.2, U101.4 (VBUSD)
unnamed: C23.1, U102.1 (dVdt)
P3V3: C22.1, R10.2, R16.2, U101.5 (CTRL), U101.12 (VDD); also elsewhere on the board
USB_5V: C25.1, U102.5 (OUT); also elsewhere on the board
USB_DM: D102.5 (IO2), J101.A7 (D-), J101.B7 (D-); also elsewhere on the board
USB_DP: D102.3 (IO1), J101.A6 (D+), J101.B6 (D+); also elsewhere on the board
USB_ILIM: R11.1, R12.1, R14.1, U102.7 (ILM)
USB_TIER1: Q101.1 (G), R13.1; also elsewhere on the board
USB_TIER2: Q102.1 (G), R15.1; also elsewhere on the board
VBUS_RAW: C24.1, D101.3 (IO1), J101.A4 (VBUS), J101.A9 (VBUS), J101.B4 (VBUS), J101.B9 (VBUS), R9.1, U102.2 (EN), U102.3 (IN), U102.4 (IN)

Notes on the sheet:
输入 eFuse
USB 侧 ESD
USB-C / USB 2.0
可分级限流 / 固件必须遵守 CC、枚举及挂起许可
此页保护仅在 USB 侧。DUT 侧不得直接挂接旧版 ESD、LED 或分压。
CC 检测

Board: 4 copper layers, 110.0 x 80.0 mm, 211 parts (0 on the bottom side), 117 nets.

Other parts of the board:
FID1, FID2, FID3: Fiducial_1mm_Mask2mm
H1, H2, H3, H4: M3 NPTH; MountingHole_3.2mm_M3
